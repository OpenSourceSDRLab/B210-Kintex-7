options:
  parameters:
    generate_options: qt_gui
    id: two_channel_loop
    output_language: python
    title: Two channel loop
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 5800e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    gain0: '0.2'
    gain1: '0.2'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    gain0: '1'
    gain1: '1'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: none
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
